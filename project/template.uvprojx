# Keil uVision project template.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: N32G452VEL7 Nationstech
  pack: Nationstech.N32G45x_DFP.1.0.4
  cpu: IRAM(0x20000000,0x24000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\CMSIS;..\User;..\Library\inc;..\User\my_head
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x24000
  group Startup
    ../Startup/: startup_n32g45x.s
  group CMSIS
    ../CMSIS/: system_n32g45x.c
  group User
    ../User/: main.c n32g45x_it.c
  group User_Library
    ../User/my_source/: Transform.c ADC.c TIM.c Control.c UART.c PLL.c
  group Library
    ../Library/src/: misc.c n32g45x_adc.c n32g45x_bkp.c n32g45x_can.c n32g45x_comp.c n32g45x_crc.c n32g45x_dac.c n32g45x_dbg.c n32g45x_dma.c n32g45x_dvp.c n32g45x_eth.c n32g45x_exti.c n32g45x_flash.c n32g45x_gpio.c n32g45x_i2c.c n32g45x_iwdg.c n32g45x_opamp.c n32g45x_pwr.c n32g45x_qspi.c n32g45x_rcc.c n32g45x_rtc.c n32g45x_sdio.c n32g45x_spi.c n32g45x_tim.c n32g45x_tsc.c n32g45x_usart.c n32g45x_wwdg.c
